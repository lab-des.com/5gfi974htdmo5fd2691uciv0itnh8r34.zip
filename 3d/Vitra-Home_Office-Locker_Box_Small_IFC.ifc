Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-10-21T15:45:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 21 15:45:24 2022 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{392AF468-552C-4A25-BD3B-1262E92B69BB}\ifc * Database version: 5507 * Database creation date: Fri Oct 21 15:45:23 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 21 15:45:24 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 21 15:45:24 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Locker Box, small Brick RE, Vitra-Home_Office-Locker_Box_Small:Locker Box, small Brick RE:348404
In: Level 1
Type - ElementType: Locker Box, small Brick RE; Material: Brick RE, Brick, Aluminium
Type - General - Author: BIMStone; BIMObjectName: Vitra-Home_Office-Locker_Box_Small; ManufacterURL: https://www.vitra.com/; ManufacturerName: Vitra; NBSDescription: Office storage; NBSReference: 45-35-80/360; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_78_90; Uniclass2015Description: Tool chests; Uniclass2015Reference: Pr_40_30_87_90; Version: 1; VersionDate: 28/09/2022
Type - Identity Data - Cost: 0; Description: Lightweight and easy to handle, the small Locker Box supports agile work routines in the office and when working from home. Thanks to this practical portable caddy, work utensils such as laptop, keyboard, papers, pens, cables, hard drives, headphones etc. are always at hand and can be simply stored away at the end of the day.; Designer: Konstantin Grcic; Manufacturer: Vitra; Model: Locker Box, small Brick RE; OmniClass Number: 23.40.20.31; OmniClass Title: Refuse Disposal Furniture; Type Name: Locker Box, small Brick RE; URL: https://www.vitra.com/living/product/details/locker-box-small
Type - Materials and Finishes - ColorMaterial: Brick; SidePanelsMaterial: Brick RE; TubesMaterial: Aluminium
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Tool dispensers; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Home_Office-Locker_Box_Small; Features: Locker Box and Locker Box small are light and easy to handle, and provide a useful tool for agile work routines in the workplace, as well as in the home offi ce. They come in a choice of colours and can be quickly dismantled if required. Name tags for personalisation are off ered in various hues.; Finish: Side panels: recycled polypropylene, 100% recyclable. Tubes: aluminium. Fabric: 100% polyester.; Grade: n/a; Material: Polypropylene,fabric and polyester; ModelNumber: n/a; ModelReference: n/a; Name: Locker_Box_Small; ReplacementCost: n/a; Shape: Sculptured; Size: 365x330x180 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.24708 m2; Volume: 0.0218592 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Vitra-Home_Office-Locker_Box_Small: Locker Box, small Brick RE; Family and Type: Vitra-Home_Office-Locker_Box_Small: Locker Box, small Brick RE; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Home_Office-Locker_Box_Small: Locker Box, small Brick RE; Type Id: Vitra-Home_Office-Locker_Box_Small: Locker Box, small Brick RE; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
