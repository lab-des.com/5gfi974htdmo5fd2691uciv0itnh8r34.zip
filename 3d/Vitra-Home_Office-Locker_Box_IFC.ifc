Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-10T13:26:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 10 13:26:19 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{8897F8BF-A3A4-4C51-996E-755042DD5FB9}\ifc * Database version: 5507 * Database creation date: Mon Jan 10 13:26:19 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 10 13:26:19 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 10 13:26:19 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Locker Box Brick RE, Vitra-Home_Office-Locker_Box:Locker Box Brick RE:425347
In: Level 1
Type - ElementType: Locker Box Brick RE; Material: Aluminium, Brick, Brick RE
Type - Dimensions - NominalDepth: 180 mm; NominalHeight: 156 mm; NominalWidth: 465 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Home_Office-Locker_Box; ManufacterURL: https://www.vitra.com/en; ManufacturerName: Vitra; NBSDescription: Waste bins; NBSReference: 45-35-72/380; ProductInformation: The Toolbox by Arik Levy is designed as a practical organisational utensil for storing accessories and small items. Thanks to its handy size, it can be easily stowed in a cabinet or on a shelf, and it takes up little room on a table. The Toolbox is available in a selection of different colours.; Revision: n/a; Uniclass2: Pr_40_70_22_92; Uniclass2015Description: Tool dispensers; Uniclass2015Reference: Pr_40_70_22_92; Version: 1; VersionDate: 22/10/2021
Type - Identity Data - Cost: 0; Description: Flexible work methods have been transforming our offices for several years now. Work is no longer confined to an assigned desk, but occurs in changing locations – according to whether the task requires productive exchanges with colleagues or quiet concentration. It is therefore practical for employees to always have their personal utensils with them. Konstantin Grcic teamed up with Vitra to develop a portable caddy that can hold everything required for work tasks – laptop, keyboard, papers, pens, cables, hard drives, headphones etc. – and is easily stored away at the end of the day.; Designer: Konstantin Grcic; Manufacturer: Vitra; Model: Locker Box Brick RE; OmniClass Number: 23.40.20.31; OmniClass Title: Refuse Disposal Furniture; Type Name: Locker Box Brick RE; URL: https://www.vitra.com/en-un/product/locker-box
Type - Materials and Finishes - ColorMaterial: Brick RE; SidePanelsMaterial: Brick; TubesMaterial: Aluminium
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Tool dispensers; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Home_Office-Locker_Box; Features: Locker Box has a simple sturdy construction. Two side panels made of recycled plastic are joined together using aluminium tubes. The top tube serves as the handle. A structure of textile panels with welded seams is suspended on the remaining five tubes to form compartments. Locker Box is light and easy to handle, and provides a useful tool for agile work routines in the workplace, as well as in the home office. It comes in a choice of colours and can be quickly dismantled if required. Name tags for personalisation are offered in various hues.; Finish: Side panels: recycled polypropylene, 100% recyclable. Tubes: aluminium. Fabric: 100% polyester.; Grade: n/a; Material: Polypropylene,fabric and polyester; ModelNumber: 20139201; ModelReference: n/a; Name: Toolbox; ReplacementCost: n/a; Shape: Sculptured; Size: 465x180x156 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.29655 m2; Volume: 0.027621 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Vitra-Home_Office-Locker_Box: Locker Box Brick RE; Family and Type: Vitra-Home_Office-Locker_Box: Locker Box Brick RE; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Home_Office-Locker_Box: Locker Box Brick RE; Type Id: Vitra-Home_Office-Locker_Box: Locker Box Brick RE; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
